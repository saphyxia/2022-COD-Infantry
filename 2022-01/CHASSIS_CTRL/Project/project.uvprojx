# Keil uVision project project.uvprojx, settings and files
target COD_CHASSIS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\APP\CAN_Receive;..\APP\remote_control;..\APP\Gyro;..\APP\Motor;..\APP\PID;..\APP\OLED;..\APP\Referee;..\APP\Irqhandler;..\TASK\Chassis_Task;..\TASK\Start_Task;..\TASK\State_Task;..\TASK\SuperCap_Task;..\BSP\Sys;..\BSP\IO_Init;..\BSP\I2C_Init;..\BSP\CAN_Init;..\BSP\iwdg_Init;..\BSP\Usart_Init;..\BSP\Timer_Init;..\BSP\Delay_Init;..\BSP\Remote_Init;..\Main;..\Startup;..\BaseMent\ARM;..\BaseMent\CMSIS;..\BaseMent\DSP\Include;..\BaseMent\FWLIB\inc;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\FreeRTOS_Middleware;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MATH\CRC;..\MATH\Kalman;..\MATH\Ramp;..\MATH\Resolve;..\TASK\IMU_Task;..\BSP\imu
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group TASK
    ../TASK/State_Task/: state_task.c
    ../TASK/Chassis_Task/: chassis_task.c
    ../TASK/SuperCap_Task/: supercap_task.c
    ../TASK/Start_Task/: start_task.c
    ../TASK/IMU_Task/: imu_task.c
  group APP
    ../APP/Motor/: motor.c
    ../APP/PID/: pid.c
    ../APP/OLED/: oled.c
    ../APP/Gyro/: gyro.c
    ../APP/Referee/: referee.c
    ../APP/Irqhandler/: Irqhandler.c
    ../APP/CAN_Receive/: CAN_receive.c
    ../APP/remote_control/: remote_control.c
  group MATH
    ../MATH/Ramp/: ramp.c
    ../MATH/CRC/: crc.c
    ../MATH/Resolve/: resolve.c
    ../MATH/Kalman/: kalman.c kalman_filter.c
  group BSP
    ../BSP/CAN_Init/: can.c
    ../BSP/Timer_Init/: timer.c
    ../BSP/IO_Init/: io_init.c
    ../BSP/Usart_Init/: usart.c
    ../BSP/I2C_Init/: myiic.c ina219.c
    ../BSP/iwdg_Init/: iwdg.c
    ../BSP/Remote_Init/: Remote_Init.c
    ../BSP/Delay_Init/: delay.c
    ../BSP/imu/: imu.c spi.c
  group Main
    ../Main/: main.c
  group Startup
    ../Startup/: startup_stm32f427xx.s
  group FreeRTOS
    ../FreeRTOS/: list.c tasks.c timers.c queue.c croutine.c event_groups.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/FreeRTOS_Middleware/: FreeRTOS_middleware.c
  group ARM
    ../BaseMent/ARM/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group CMSIS
    ../BaseMent/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group DSP
    ../BaseMent/DSP/: arm_cortexM4lf_math.lib
  group FWLIB
    ../BaseMent/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
