# Keil uVision project project.uvprojx, settings and files
target COD_Gimbal_Task (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\stm32LIB\inc;..\stm32LIB\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\_Dsp\Include;..\user\_Bsp;..\user\_Task;..\system;..\stm32LIB\CMSIS;..\system;..\FreeRTOS;..\user;..\user\_Dsp;..\user\_Dsp\Include;..\user\_Algorithms;..\user\_Device;..\user\_Bsp\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../user/: main.c
    ../FreeRTOS/: FreeRTOS_Init.c
  group Task
    ../user/_Task/: gimbal_Task.c imu_Task.c dbus_Task.c shoot_Task.c cover_Task.c state_Task.c vision_Task.c systemState_Task.c
  group Algorithms
    ../user/_Algorithms/: filter.c pid.c assist.c temp_pid.c
  group Bsp
    ../user/_Bsp/: can1.c can2.c uart1.c uart2.c spi.c gpio.c flash.c tim.c rc.c AHRS_middleware.c user_lib.c myiic.c AHRS.lib Matrix.c
  group Device
    ../user/_Device/: bmi088.c bmi088Middleware.c ist8310.c ist8310Middleware.c gimbal.c shoot.c trigger.c vision.c JY901.c
  group FPU
    ../stm32LIB/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_trans_f32.c arm_mat_sub_f32.c
    ../user/_Dsp/: arm_cortexM4lf_math.lib
  group STMLIB
    ./: startup_stm32f407xx.s
    ../stm32LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_i2c.c stm32f4xx_fsmc.c
    ../stm32LIB/CMSIS/: system_stm32f4xx.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group System
    ../system/: sys.c system.c
