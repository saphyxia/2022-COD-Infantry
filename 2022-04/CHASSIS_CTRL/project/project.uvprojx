# Keil uVision project project.uvprojx, settings and files
target COD_CHASSIS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\system;..\User\main;..\FreeRTOS;..\User\_DSP\Include;..\User\_Task\Chassis_Task;..\User\_Task\Referee_Task;..\User\_Task\Power_Task;..\User\_Task\State_Task;..\User\_Algorithm\assist;..\User\_Algorithm\kalman;..\User\_Algorithm\crc;..\User\_Algorithm\pid;..\User\_Bsp\delay;..\User\_Bsp\can;..\User\_Bsp\gpio;..\User\_Bsp\iic;..\User\_Bsp\imu;..\User\_Bsp\iwdg;..\User\_Bsp\rc;..\User\_Bsp\adc;..\User\_Bsp\dac;..\User\_Bsp\timer;..\User\_Bsp\uasrt;..\User\_Deviece\UI;..\User\_Deviece\chassis;..\User\_Deviece\motor;..\User\_Deviece\referee;..\STM32LIB\Device;..\STM32LIB\CMSIS;..\STM32LIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/main/: main.c
    ../FreeRTOS/: FreeRTOS_Init.c
  group Task
    ../User/_Task/Chassis_Task/: Chassis_Task.c
    ../User/_Task/State_Task/: State_Task.c
    ../User/_Task/Power_Task/: Power_Task.c
  group Algorithms
    ../User/_Algorithm/assist/: assist.c
    ../User/_Algorithm/kalman/: filter.c
    ../User/_Algorithm/pid/: pid.c temp_pid.c
    ../User/_Algorithm/crc/: crc.c
  group BSP
    ../User/_Bsp/rc/: rc.c
    ../User/_Bsp/can/: can.c
    ../User/_Bsp/uasrt/: usart.c
    ../User/_Bsp/gpio/: gpio.c
    ../User/_Bsp/iwdg/: iwdg.c
    ../User/_Bsp/timer/: timer.c
    ../User/_Bsp/iic/: myiic.c
    ../User/_Bsp/delay/: delay.c
    ../User/_Bsp/adc/: adc.c
    ../User/_Bsp/dac/: dac.c
    ../User/_Bsp/imu/: imu.c spi.c
  group Device
    ../User/_Deviece/chassis/: chassis.c
    ../User/_Deviece/motor/: motor.c
    ../User/_Bsp/iic/: ina226.c
    ../User/_Deviece/referee/: referee.c referee_info.c
    ../User/_Deviece/UI/: UI.c
  group FPU
    ../STM32LIB/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../User/_DSP/: arm_cortexM4lf_math.lib
  group STMLIB
    ../STM32LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../STM32LIB/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group System
    ../system/: sys.c system.c
    ./: startup_stm32f427xx.s
